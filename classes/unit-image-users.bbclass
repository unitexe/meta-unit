IMAGE_INSTALL:append = " packagegroup-unit-user-management"
