IMAGE_INSTALL:append = " packagegroup-unit-ebpf"
