SUMMARY = "Unit demo"
DESCRIPTION = "Demonstrate using unit yocto"
AUTHOR = "unitexe"
SECTION = "unit"
LICENSE = "MIT"

inherit unit-image
